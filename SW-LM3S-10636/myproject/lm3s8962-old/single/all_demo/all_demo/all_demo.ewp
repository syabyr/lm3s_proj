# IAR project all_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx1xx TexasInstruments LM3Sx1xx
  ICCARM.CCIncludePath2: F:\IAR Project\all_demo; F:\IAR Project\common_doc\StellarisWare\driver lib\driverlib; F:\IAR Project\common_doc\StellarisWare\driver lib\inc; F:\IAR Project\common_doc\StellarisWare\graph lib\grlib; F:\IAR Project\common_doc\StellarisWare\driver lib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: all_demo.out
  ILINK.IlinkIcfFile: F:\IAR Project\common_doc\LM3S2110.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../common_doc/: driverlib.a grlib.a
  group src
    ./: 320x240_lcd_ssd1963.c appfunc.c images.c main.c pca9534.c sound.c touch.c ustdlib.c
  group start up
    ./: startup_ewarm.c
