# Keil uVision project temperature_sensor.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S615 Luminary Micro
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: temperature_sensor +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    D:/Keil/ARM/RV31/LIB/Luminary/: DriverLib.lib
    ./: Startup.s ADC0_TEMP1.C
