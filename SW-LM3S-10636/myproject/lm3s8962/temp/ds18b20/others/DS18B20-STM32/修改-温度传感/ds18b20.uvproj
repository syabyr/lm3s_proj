# Keil uVision project ds18b20.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ds18b20 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Initlization
    ./: STM32F10x.s STM32_Init.c
  group Drivers
    ./: TFT200.c
  group Application
    ./: main.c ds18b20.h ds18b20.c
  group LIB
    ./: STM32F10xR.LIB
