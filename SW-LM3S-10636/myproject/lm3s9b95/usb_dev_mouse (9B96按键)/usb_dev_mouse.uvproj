# Keil uVision project usb_dev_mouse.uvproj, settings and files
target usb_dev_mouse (ARM-ADS)
  device: LM3S9B96 Luminary Micro
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_dev_mouse
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_mouse.bin .\rvmdk\usb_dev_mouse.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S3748 UART_BUFFERED TARGET_IS_DUSTDEVIL_RA0
  c include: D:\StellarisWare(eklm3s3748);..\..\..\boards\ek-lm3s3748
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S
    ../../../utils/: uartstdio.c
    ./: usb_dev_mouse.c usb_mouse_structs.c
  group Libraries
    ../../../driverlib/rvmdk/: driverlib.lib
    ../../../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
